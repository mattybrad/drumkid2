File: pcb/dk2_04_panel/dk2_04_panel.kicad_sch (KiCad schematic)
At the start: 55 parts

Commit message: autosave works
Parts:
- H17: value Other -> Tom
