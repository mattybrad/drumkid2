File: pcb/dk2_04_panel/dk2_04_panel.kicad_pcb (KiCad board)
At the start: 2 copper layers, 121.9 x 128.5 mm, 55 parts

Commit message: autosave works
Parts:
- H17: value OTHER -> TOM
